# CVE_STATUS — narrowly-evidenced VEX for sbom-cve-check matches already fixed
# in the shipped version.
#
# CVE-2024-6345: fixed at setuptools 70.0.0; shipped 82.0.1.
# https://nvd.nist.gov/vuln/detail/CVE-2024-6345
CVE_STATUS[CVE-2024-6345] = "fixed-version: fixed in setuptools 70.0.0; shipped 82.0.1"
