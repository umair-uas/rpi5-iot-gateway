# CVE_STATUS — narrowly-evidenced VEX for sbom-cve-check matches already fixed
# in the shipped version.
#
# CVE-2025-31498: fixed by the c-ares 1.34.5 security release; shipped 1.34.6.
# https://nvd.nist.gov/vuln/detail/CVE-2025-31498
CVE_STATUS[CVE-2025-31498] = "fixed-version: fixed in c-ares 1.34.5; shipped 1.34.6"
