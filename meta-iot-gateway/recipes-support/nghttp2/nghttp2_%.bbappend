# CVE_STATUS — narrowly-evidenced VEX for sbom-cve-check matches already fixed
# in the shipped version.
#
# CVE-2026-27135: fixed in the nghttp2 1.68.1 release (shipped).
# https://nvd.nist.gov/vuln/detail/CVE-2026-27135
CVE_STATUS[CVE-2026-27135] = "fixed-version: fixed in nghttp2 1.68.1 (shipped)"
