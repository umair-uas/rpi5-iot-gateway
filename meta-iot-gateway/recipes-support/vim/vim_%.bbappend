# CVE_STATUS — narrowly-evidenced VEX for sbom-cve-check matches already fixed
# in the shipped version.
#
# CVE-2024-43802: fixed in Vim patch 9.1.0697; shipped 9.2.x is past that.
# https://nvd.nist.gov/vuln/detail/CVE-2024-43802
CVE_STATUS[CVE-2024-43802] = "fixed-version: fixed in vim 9.1.0697; shipped 9.2.x"
